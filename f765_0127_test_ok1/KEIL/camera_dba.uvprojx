# Keil uVision project camera_dba.uvprojx, settings and files
target stm32f765 (ARM-ADS)
  device: STM32F765IGKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: camera_dba +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../include;../HAL/include;../HAL/include/Legacy;../core/include;../external/LwIP/src/include;../external/LwIP/system;../external/LwIP/src/include/netif/ppp;../external/LwIP/src/include/lwip;../external/LwIP/src/include/lwip/apps;../external/LwIP/src/include/lwip/priv;../external/LwIP/src/include/lwip/prot;../external/LwIP/src/include/netif;../external/LwIP/src/include/posix;../external/LwIP/src/include/posix/sys;../external/LwIP/system/arch;C:\Keil_v5\ARM\ARMCC\include;..\sii9136-3\hal;..\sii9136-3\Timers;..\sdi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\core\STMFLASH.sct
  group core
    ../core/: startup_stm32f765xx.s
  group driver
    ../driver/led/: led.c
    ../driver/romflash/: romflash.c
    ../driver/input/: key.c
    ../driver/dma/: dma.c
    ../driver/i2c/: i2c1.c i2c2.c i2c3.c i2c4.c
    ../driver/spi/: spi1.c spi4.c spi5.c spi6.c spi_common.c
    ../driver/usart/: uart3.c uart4.c uart2.c
    ../driver/gps_pps/: gps_pps.c
    ../driver/iwdg/: iwdg.c
    ../driver/oled/: oled.c
    ../driver/rtc/: rtc.c
    ../driver/oled_meau/: main_meau.c meau_flash.c meau_status_list.c meau_system_list.c menu.c menu_items.c
  group app
    ../app/: main.c ethernetif.c lwip.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c wlan_check.c pollint.c udp_api.c eventManage.c power.c config_env.c mboot.c tsmux.c adv7619.c delay.c
  group external/LwIP
    ../external/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../external/LwIP/src/netif/ppp/: ccp.c auth.c demand.c ecp.c eap.c eui64.c pppapi.c ipcp.c chap_ms.c magic.c fsm.c pppos.c mppe.c chap-new.c vj.c pppol2tp.c ppp.c ipv6cp.c upap.c pppoe.c chap-md5.c lcp.c pppcrypt.c multilink.c utils.c
    ../external/LwIP/src/core/ipv4/: icmp.c dhcp.c ip4.c etharp.c ip4_addr.c ip4_frag.c autoip.c igmp.c
    ../external/LwIP/src/core/: udp.c stats.c raw.c pbuf.c inet_chksum.c tcp_out.c mem.c timeouts.c tcp_in.c netif.c tcp.c init.c dns.c def.c ip.c memp.c sys.c
    ../external/LwIP/src/api/: sockets.c netbuf.c netdb.c tcpip.c api_lib.c err.c api_msg.c netifapi.c
    ../external/LwIP/src/core/ipv6/: mld6.c ip6.c ethip6.c ip6_addr.c inet6.c ip6_frag.c icmp6.c dhcp6.c nd6.c
  group HAL
    ../HAL/: stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c
  group sii9136-3/tpi
    ../sii9136-3/tpi/: sii9136_3_main.c AV_Config.c EDID.c eHDMI.c Event.c Globals.c HDCP.c i2c_master_sw.c SerialPort.c SimConfig.c TPI.c TPI_Access.c Util.c VideoModeTable.c
  group sii9136-3/Timers
    ../sii9136-3/Timers/: hal_timers.c hal_timers_elapsed.c hal_timers_expired.c hal_timers_set.c hal_timers_wait.c
  group sdi
    ../sdi/: sdi_rx.c sdi_tx.c
